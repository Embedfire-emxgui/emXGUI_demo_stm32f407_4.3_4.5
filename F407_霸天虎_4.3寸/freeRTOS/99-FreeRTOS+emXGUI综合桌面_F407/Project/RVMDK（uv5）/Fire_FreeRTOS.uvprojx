# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,X_GUI_USE_FREERTOS,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\User\bsp;..\..\..\..\..\emXGUI_Lib\inc;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib\app\base;..\..\..\..\..\emXGUI_Lib\arch;..\..\User\bsp\FATFS\option;..\..\User\bsp\FATFS;..\..\User\app\GUI_Demo;..\..\..\..\..\emXGUI_Lib\libs;..\..\User\app\Board_App\rgb_led;..\..\User\OwnerDraw;..\..\User\app\Board_App;..\..\User\app\Board_App\LED_Key;..\..\User\app\Board_App\clock;..\..\User\app\Board_App\adc_Collect_voltage;..\..\User\app\Board_App\mp3_decoder;..\..\User\app\Board_App\mp3_player;..\..\User\app\Board_App\recorder;..\..\User\app\Board_App\mp3_decoder\real;..\..\User\app\Board_App\mp3_decoder\pub;..\..\User\bsp\cm_backtrace;..\..\User\app\Board_App\T_RH;..\..\User\app\Board_App\SimulateUDisk;..\..\User\app\Board_App\SimulateUDisk\USB_app;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\..\..\emXGUI_Lib\app\base\boot_interface\pic_load;..\..\User\app\Board_App\camera;..\..\User\app\Board_App\Phone_SMS;..\..\User\app\Board_App\WiFi;..\..\User\app\Board_App\network\LAN8742A;..\..\User\app\Board_App\network\lwip-1.4.1;..\..\User\app\Board_App\network\lwip-1.4.1\port;..\..\User\app\Board_App\network\lwip-1.4.1\src;..\..\User\app\Board_App\network\lwip-1.4.1\src\include;..\..\User\app\Board_App\network\lwip-1.4.1\src\include\netif;..\..\User\app\Board_App\network\lwip-1.4.1\src\include\lwip;..\..\User\app\Board_App\network\lwip-1.4.1\src\include\ipv4;..\..\User\app\Board_App\network\lwip-1.4.1\port\arch;..\..\User\app\Board_App\network\lwip-1.4.1\port\FreeRTOS305;..\..\User\app\Board_App\network\lwipapp;..\..\User\app\Board_App\network
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Output\Fire_FreeRTOS.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h
  group BSP
    ../../User/bsp/uart/: bsp_debug_usart.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/fsmc/: bsp_fsmc.c
    ../../User/bsp/flash/: bsp_spi_flash.c
    ../../User/bsp/sdio/: bsp_sdio_sd.c
    ../../User/bsp/dwt_delay/: core_delay.c
    ../../User/bsp/beep/: bsp_beep.c
    ../../User/bsp/lcd/: DMA_LCD.c bsp_nt35510_lcd.c
    ../../User/bsp/touch/: bsp_i2c_touch.c gt9xx.c
  group cm_backtrace
    ../../User/bsp/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../../User/bsp/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Fatfs
    ../../User/bsp/FATFS/: diskio.c ff.c
    ../../User/bsp/FATFS/option/: cc936.c extern_cc936.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group emxgui/arch
    ../../../../../emXGUI_Lib/arch/: GUI_GPU.c GUI_Arch.c EXT_LCD_Arch.c
    ../../../../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
  group emxgui/resource
    ../../../../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../../../../emXGUI_Lib/drv/: gui_lcd_port.c gui_log_port.c gui_font_port.c gui_mem_port.c gui_startup.c gui_touch_port.c gui_input_port.c gui_resource_port.c gui_fs_port.c gui_picture_port.c
  group emxgui/inc
    ../../../../../emXGUI_Lib/inc/: def.h emXGUI.h emXGUI_Arch.h GUI_Font_XFT.h x_libc.h x_obj.h
  group emxgui/libs
    ../../../../../emXGUI_Lib/libs/: emXGUI100_MDK_M4.lib x_libc_MDK_M4.lib libpng_MDK_M4.lib libjpeg_MDK_M4.lib x_obj.cpp
  group base_app
    ../../../../../emXGUI_Lib/app/base/: gui_desktop.c
    ../../../../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../../../../emXGUI_Lib/app/base/res_writer/: GUI_RES_Writer_Dialog.c backend_res_writer.c
  group gui_app
    ../../User/app/GUI_Demo/: GUI_DEMO_SlideWindow.c CListMenu.cpp GUI_App_Desktop.c GUI_DEMO_ShowWave.cpp GUI_DEMO_Graphics_Accelerator.c GUI_DEMO_RectSpeed.c GUI_DEMO_Settings.c GUI_SelectDialogBox.c GUI_DEMO_Number_Keyboard.c calculator.cpp
    ../../User/app/Board_App/: GUI_Board_App_Desktop.c
    ../../User/OwnerDraw/: Widget.c
  group OEM_Face
    ../../../../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_TextBox.c OEM_ScrollBar.c
  group DOC
    ../../: 必读说明.txt
  group app_res
    ../../../../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group tutorial/music_record
    ../../User/app/Board_App/mp3_player/wm8978/: bsp_wm8978.c
    ../../User/app/Board_App/mp3_player/: Backend_mp3Player.c GUI_MusicList_DIALOG.c GUI_MUSICPLAYER_DIALOG.c
    ../../User/app/Board_App/recorder/: GUI_RECORDER_DIALOG.c Backend_Recorder.c
  group tutorial/rgbled
    ../../User/app/Board_App/rgb_led/: Backend_RGBLED.c GUI_RGBLED_DIALOG.c
  group tutorial/led_key
    ../../User/app/Board_App/LED_Key/: GUI_LED_KEY_Dialog.c
  group tutorial/clock
    ../../User/app/Board_App/clock/: GUI_CLOCK_DIALOG.c
    ../../User/app/Board_App/clock/rtc/: bsp_rtc.c bsp_date.c
  group tutorial/beeper
    ../../User/app/Board_App/beeper_control/: GUI_Beeper_Dialog.c
  group tutorial/adc
    ../../User/app/Board_App/adc_Collect_voltage/: GUI_ADC_CollectVoltage_Dialog.c bsp_adc.c
  group MP3_decoder
    ../../User/app/Board_App/mp3_decoder/: mp3dec.c mp3tabs.c
    ../../User/app/Board_App/mp3_decoder/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../User/app/Board_App/mp3_decoder/real/arm/: asmpoly_thumb2.s asmmisc.s
  group tutorial/T_RH
    ../../User/app/Board_App/T_RH/: GUI_T_RH_Dialog.c
    ../../User/app/Board_App/T_RH/dht11/: bsp_dht11.c
  group tutorial/U_Disk
    ../../User/app/Board_App/SimulateUDisk/: GUI_SimulateUDisk_Dialog.c
    ../../User/app/Board_App/SimulateUDisk/USB_app/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group USB Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB Device
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group tutorial/camera
    ../../User/app/Board_App/camera/: GUI_Camera_Dialog.c bsp_ov5640.c ov5640_AF.c
  group tutorial/Phone_SMS
    ../../User/app/Board_App/Phone_SMS/: GUI_Phone_Dialog.c GUI_SMS_Dialog.c
    ../../User/app/Board_App/Phone_SMS/sim900a/: bsp_sim900a.c bsp_usart_gsm.c
  group tutorial/Wi-Fi
    ../../User/app/Board_App/WiFi/: GUI_WiFi_Dialog.c
    ../../User/app/Board_App/WiFi/ESP8266/: bsp_esp8266.c
  group tutorial/network
    ../../User/app/Board_App/network/: GUI_network_Dialog.c
    ../../User/app/Board_App/network/LAN8742A/: LAN8742A.c stm32f429_eth.c
    ../../User/app/Board_App/network/lwipapp/: netconf.c tcp_echoclient.c tcp_echoserver.c tcpecho.c udp_echoclient.c
  group LwIP
    ../../User/app/Board_App/network/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../User/app/Board_App/network/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../User/app/Board_App/network/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../User/app/Board_App/network/lwip-1.4.1/src/netif/: etharp.c
    ../../User/app/Board_App/network/lwip-1.4.1/port/FreeRTOS305/: ethernetif.c sys_arch.c
